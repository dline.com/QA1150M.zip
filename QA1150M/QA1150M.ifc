Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-10-21T10:08:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.0.2.392 - Alternate UI 22.0.2.392
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 21 10:08:29 2022 * Host: DLI-L5jdgnbTSD7 * Database: C:\Users\gba\AppData\Local\Temp\c1b253e7-b555-4074-b52a-e9626611f7da\d8dfb521-84fa-46f7-87a5-d274b5895642\ifc * Database version: 5507 * Database creation date: Fri Oct 21 10:08:25 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Oct 21 10:08:25 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 21 10:08:25 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 ft
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_ProductRequirements - Category: Project Information
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:1/4" Head, First Floor
LongName: First Floor; Elevation: 0 ft
Pset_ProductRequirements - Name: First Floor; Category: Levels
Pset_AirSideSystemInformation - Name: First Floor

# IfcFlowTerminal: QA1150M:QTOO_QA1150M_PushOpenAnti-bacterialDrainBrushed, QA1150M:QTOO_QA1150M_PushOpenAnti-bacterialDrainBrushed:565475
In: First Floor
Type - PredefinedType: WASTETRAP; Material: AISI 316
Type - Pset_ElementShading - Color: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: MasterFormat2014Code - 10 28 16: Bath Accessories; Manufacturer: info@qtoobath.com
Type - Pset_ProductRequirements - Name: QTOO_QA1150M_PushOpenAnti-bacterialDrainBrushed; Category: Generic Models
Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: QTOO_QA1150M_PushOpenAnti-bacterialDrainBrushed; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
